# Keil uVision project project.uvproj, settings and files
target file_list (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: program +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,VECT_TAB_SRAM
  c include: ..\Stm32lib\user_inc;..\Stm32lib\inc;..\user\include;..\..\board\inc
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x8000
  memory RVCT9: RAM 0x20008000 size 0x8000
  group RVMDK
    ./: startup_stm32f10x_hd.s
  group StdPeriphDeriver
    ../Stm32lib/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c RCC_Configuration.c nvic_misc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
    ../Stm32lib/CMSIS/: core_cm3.c
    ../Stm32lib/src_base/: delay.c COM_USART1.c usart.c ADC_init.c
  group User
    ../user/src/: led.c main.c stm32f10x_it.c
